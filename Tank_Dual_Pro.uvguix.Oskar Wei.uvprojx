# Keil uVision project Tank_Dual_Pro.uvguix.Oskar Wei.uvprojx, settings and files
target Target (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Tank_Dual_Pro +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\Src\BSP\CMSIS\CM3\CoreSupport;.\Src\BSP\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\Src\FatFs;.\Src\STM32F10x_StdPeriph_Driver\inc;.\Src\BSP;.\Src\User;.\Src\FreeRTOS\portable\RVDS\ARM_CM3;.\Src\FreeRTOS\include;.\Src\System;.\Src\EKF
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ./Src/User/: main.c stm32f10x_it.c
  group System
    ./Src/System/: sensors.c filter.c utils.c radio.c obstacle.c
  group EKF
    ./Src/EKF/: ekf.c matrix.c quaternion.c fast_math.c mini_matrix.c double_matrix.c ekf2.c
  group BSP
    ./Src/BSP/: usart1.c uart4.c uart5.c adc.c led.c flash.c spi_flash.c key.c can.c i2c_oled.c delay.c buzzer.c servo.c motor.c i2c_driver.c i2c_device.c mpu9250.c ak8963.c nrf24l01.c watchdog.c power_control.c
    ./Src/BSP/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ./Src/BSP/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group FatFs
    ./Src/FatFs/: diskio.c ff.c
    ./Src/FatFs/option/: cc936.c
  group STM32F10x_StdPeriph_Driver
    ./Src/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group FreeRTOS
    ./Src/FreeRTOS/: list.c queue.c tasks.c timers.c
    ./Src/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ./Src/FreeRTOS/portable/MemMang/: heap_4.c
  group Readme
    ./Src/: readme.txt
